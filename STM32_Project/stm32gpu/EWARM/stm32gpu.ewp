# IAR project stm32gpu.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stm32gpu.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\Drivers\STM32F10x_StdPeriph_Driver\inc\; ..\..\Drivers\STM32F10x_StdPeriph_Driver\src\; ..\..\Drivers\CMSIS\; ..\..\Drivers\systicktimer\; ..\..\Drivers\stmSPI\; ..\..\Drivers\uart\; ..\..\Drivers\gfx_tft\; ..\..\Drivers\ILI9341\; ..\..\Drivers\fsmc\; ..\..\Drivers\FatFS\; ..\..\Drivers\memory\; ..\..\Drivers\sound\; ..\..\Drivers\raycasterEngine\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: stm32gpu.bin
  ILINK.IlinkIcfFile: f103c8t6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c
  group common
    ../../Drivers/memory/: memHelper.c memHelper.h
  group Drivers/FatFS
    ../../Drivers/FatFS/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h sdcard_spi.c sdcard_spi.h
  group Drivers/FSMC
    ../../Drivers/fsmc/: fsmcdrv.c fsmcdrv.h
  group Drivers/GFX_TFT
    ../../Drivers/gfx_tft/: fonts.h gfx.c gfx.h
  group Drivers/GFX_TFT/ILI9341
    ../../Drivers/ILI9341/: ili9341.c ili9341.h
  group Drivers/RaycasterEngine
    ../../Drivers/raycasterEngine/: raycast.c raycast.h
  group Drivers/Sound
    ../../Drivers/sound/: tone.c tone.h
  group Drivers/SPI
    ../../Drivers/stmSPI/: spi.c spi.h
  group Drivers/SysTickTimer
    ../../Drivers/systicktimer/: systicktimer.c systicktimer.h
  group Drivers/UART
    ../../Drivers/uart/: uart.c uart.h
  group GPU/common
    ../: landscapeTileMap.h landscapeTileset.h nesPalette_ext.h stm_gpu_nes_tiles2.h stm_gpu_nes_tilesMap.h STMsGPU_Palette.h
  group GPU/core GPU
    ../: gpuMain.c gpuMain.h initGPU.c logoGPU.c
  group GPU/gui
    ../: gui.c gui.h
  group GPU/SD card
    ../: sdLoader.c sdLoader.h
  group GPU/sprites
    ../: sprites.c sprites.h
  group GPU/tiles
    ../: gpuTiles.c gpuTiles.h
  group STM32_SPL_Core/inc
    ../../Drivers/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_dma.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h
  group STM32_SPL_Core/src
    ../../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32_SPL_Core/Startup
    ../../Drivers/CMSIS/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group STM32_SPL_Core/STM32F10x
    ../../Drivers/CMSIS/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
